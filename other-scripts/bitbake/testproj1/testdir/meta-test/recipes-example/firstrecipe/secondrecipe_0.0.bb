DESCRIPTION = "Our first recipe for bitbake hello world"

inherit autotool


